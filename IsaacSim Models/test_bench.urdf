Commit message: add files

File: IsaacSim Models/test_bench.urdf (robot description, URDF)
Before this commit: robot test_bench, 4 links, 3 joints
Links:
- link scoop: geometry collision mesh filename=.\Assets\scoopandmount.stl; visual mesh filename=.\Assets\scoopandmount.stl
